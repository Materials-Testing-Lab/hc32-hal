<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adt_hw_start_stop_clear.ewp</path>
  </project>
  <batchBuild/>
</workspace>


