# Keil uVision project timer3_m23_pwm_port_brake.uvprojx, settings and files
target timer3_m23_pwm_port_brake_Release (6100001::V6.10.1::.\ARMCLANG)
  device: HC32L196PCTA HDSC
  pack: HDSC.HC32L19x.1.1.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: timer3_m23_pwm_port_brake +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l19x.s
    ../../../../mcu/common/: system_hc32l19x.c interrupts_hc32l19x.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c timer3.c gpio.c flash.c adc.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
